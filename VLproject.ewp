# IAR project VLproject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 30
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: IndicatorRus1\Inc; General\Inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.cpp
  group General
    General/: gsm.cpp gsmUartCommands.cpp interrupts.cpp peripherals.cpp
  group General/Inc
    General/Inc/: gsm.hpp gsm_mainTitle.hpp gsmUartCommands.hpp peripherals.hpp
  group IndicatorRus1
    IndicatorRus1/: example_base_functions.cpp example_base_strings.cpp example_options.cpp example_work.cpp rus1.cpp rus1_indicatorRUS1.cpp rus1_interruptLcdTimer.cpp rus1_peripherals.cpp rus1_screenLCD_AC-162A.cpp rus1_stencil_funcs_changedata.cpp rus1_treenode_go.cpp vl_TreeStructureGenerator_Functions.cpp vl_TreeStructureGenerator_Structure.cpp
  group IndicatorRus1/Inc
    IndicatorRus1/Inc/: example_base_functions.hpp example_base_strings.hpp example_base_types.hpp example_options.hpp example_work.hpp rus1.hpp rus1_indicatorRUS1.hpp rus1_interruptLcdTimer.hpp rus1_mainTitle.hpp rus1_peripherals.hpp rus1_screenLCD_AC-162A.hpp rus1_stencil_funcs_changedata.hpp rus1_treenode_go.hpp vl_TreeStructureGenerator_Functions.hpp vl_TreeStructureGenerator_Structure.hpp
